# Keil uVision project Project01_learn_Bootloader_led.uvprojx, settings and files
target Project01_learn_Bootloader_led (5050106::V5.05 update 1 (build 106)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8008000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: Project01_learn_Bootloader_led +hex
  AfterMake: D:\Keil5\ARM\ARMCC\bin\fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Protocol/CAN;../Protocol/SPI;../Protocol/I2C;../Driver/Storage;../Driver/MCU;../BSP;../Service;../APP
  library: MicroLIB
  memory RVCT4: ROM 0x8008000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c can.c crc.c dma.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_can.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_crc.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Protocol
    ../Protocol/CAN/: can_buf.c can_buf.h can_proto.h
    ../Protocol/SPI/: soft_spi.c
    ../Protocol/I2C/: soft_i2c.c
  group Driver
    ../Driver/Storage/: w25q16.c at24c02.c at24c02.h w25q16.h
    ../Driver/MCU/: crc32.c crc32.h
  group APP
    ../APP/: app_ota_update.c app_ota_update.h
  group BSP
    ../BSP/: bsp_soft_i2c.c bsp_soft_i2c.h bsp_soft_spi.c bsp_soft_spi.h
  group Service
    ../Service/: ota_storage.c ota_storage.h
software components: CMSIS:CORE 4.3.0
